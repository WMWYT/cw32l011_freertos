# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L011_DFP.1.0.1
  cpu: IRAM(0x20000000,0x01800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\IdeSupport\MDK;..\Libraries\inc;..\USER\inc;..\StartKit_Board;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../IDEsupport/: startup_cw32l011.s
    ../Libraries/src/: system_cw32l011.c
  group User
    ../USER/src/: main.c interrupts_cw32l011.c
  group Driver
    ../Libraries/src/: cw32l011_sysctrl.c cw32l011_gpio.c cw32l011_flash.c
  group Doc
    ../: readme.txt
  group Bsp
    ../StartKit_Board/: cw32l011_startkit_board.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/RVDS/ARM_CM0/: mpu_wrappers_v2_asm.c port.c portasm.c
    ../FreeRTOS/portable/RVDS/MemMang/: heap_4.c
software components: CMSIS:CORE 6.1.0
